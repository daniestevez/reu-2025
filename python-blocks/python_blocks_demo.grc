options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: python_blocks_demo2
    output_language: python
    title: Python blocks demo
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: round(samp_rate / nfft)
  states: {}
- name: frequency
  id: variable_qtgui_entry
  parameters:
    label: RF frequency (Hz)
    type: real
    value: 98e6
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: time_integration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    M: M
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, M=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='Spectral Kurtosis',   # will show up in GRC
                  in_sig=[(np.complex64, 4096)],
                  out_sig=[(np.float32, 4096)],
                  decim=M
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.M = M
              self.nfft = 4096

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print('output_items[0].shape =', output_items[0].shape)
              #print('input_items[0].shape =', input_items[0].shape)
              M = self.M
              x = input_items[0].reshape(-1, M, self.nfft)
              z = x.real**2 + x.imag**2
              kurtosis = (M / (M - 1)) * ((M + 1) * np.sum(z**2, axis=1) / np.sum(z, axis=1)**2 - 2)
              output_items[0][:] = kurtosis
              return len(output_items[0])
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Spectral kurtosis"'
    vlen: nfft
    x_axis_label: '"Frequency (MHz)"'
    x_start: '- samp_rate / 2 * 1e-6'
    x_step: samp_rate / nfft * 1e-6
    x_units: '"MHz"'
    y_axis_label: '"Spectral kurtosis"'
    ymax: '40'
    ymin: '-5'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: frequency
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']
- [fft_vxx_0, '0', epy_block_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
