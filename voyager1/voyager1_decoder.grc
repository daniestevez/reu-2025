options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: voyager1_decoder
    output_language: python
    title: Voyager-1 decoder
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '320'
  states: {}
- name: cc_decoder_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[-109, 79]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: 4 * 239
  states: {}
- name: freq
  id: variable
  parameters:
    value: '-379.15e3'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.5 * samp_rate / decimation
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.1 * samp_rate / decimation
    win: window.WIN_HAMMING
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate / (baudrate * decimation * decimation2)
  states: {}
- name: subcarrier_freq
  id: variable
  parameters:
    value: '22497.3'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '''03915ED3'''
  states: {}
- name: syncword_bits
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword), 'uint8')).astype('int') - 1
  states: {}
- name: syncword_string
  id: variable
  parameters:
    value: '''''.join([''0'' if a == -1 else ''1'' for a in syncword_bits])'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bw * decimation / samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: vgr1_blc23_guppi_59046_80036_DIAG_VOYAGER-1_0011.cs8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '128'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: frame_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 10
    type: complex
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: frame_size
    type: byte
    vector: list(bytes.fromhex(syncword))
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1 / round(sps)] * round(sps)'
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_bits[::-1]/syncword_bits.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_bits[::-1]/syncword_bits.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier_freq
    decim: decimation2
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1, 1, 0.5/decimation2, 0.1/decimation2)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0
    name: Constellation
    size: 2 * baudrate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    label1: In-phase (residual carrier)
    label2: Quadrature (data subcarrier)
    name: PLL output spectrum
    nconnections: '2'
    type: float
    ymax: '-60'
    ymin: '-85'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation / decimation2
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,1
    name: Data subcarrier spectrum
    type: complex
    ymax: '-70'
    ymin: '-90'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 1,1
    label1: Decoder 0 output symbols
    label2: Decoder 0 syncword correlation
    label3: Decoder 1 output symbols
    label4: Decoder 1 syncword correlation
    name: Viterbi decoder output symbols
    nconnections: '4'
    size: 7680 * 2
    srate: baudrate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '1'
    gfpoly: '0x11d'
    interleave: '4'
    nroots: '32'
    nsym: '8'
    prim: '1'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: frame_size - 4
    sync: syncword_string
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: frame_size - 4
    sync: syncword_string
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: frame_size - 4
    sync: syncword_string
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_1
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: frame_size - 4
    sync: syncword_string
    threshold: '0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', fir_filter_xxx_1, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_real_0, '0', fec_extended_decoder_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_delay_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_not_xx_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [blocks_not_xx_0_0, '0', satellites_sync_to_pdu_packed_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', blocks_vector_insert_x_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_decoder_0, '0', blocks_not_xx_0_0, '0']
- [fec_extended_decoder_0, '0', satellites_sync_to_pdu_packed_0_1, '0']
- [fec_extended_decoder_0_0, '0', blocks_char_to_float_0_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_not_xx_0, '0']
- [fec_extended_decoder_0_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0, '3']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_0, in]
- [satellites_decode_rs_0, out, blocks_message_debug_0, print]
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_sync_to_pdu_packed_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_sync_to_pdu_packed_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_sync_to_pdu_packed_0_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_sync_to_pdu_packed_0_1, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
