options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: fm_broadcast
    output_language: python
    title: FM broadcast receiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_entry
  parameters:
    label: Audio gain
    type: real
    value: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: RF frequency
    type: real
    value: 98.5e6
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '3'
  states: {}
- name: pll_range
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF gain
    type: real
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3_200_000'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.5 * samp_rate / decimation
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.1 * samp_rate / decimation
    win: window.WIN_HAMMING
  states: {}
- name: tune_freq
  id: variable_qtgui_entry
  parameters:
    label: Tune frequency
    type: real
    value: 300e3
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * np.pi * decimation * (19e3 + pll_range) / samp_rate
    min_freq: 2 * np.pi * decimation * (19e3 - pll_range) / samp_rate
    w: 2 * np.pi * decimation * pll_bw / samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / (2 * np.pi * deviation * decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/reu-2024/fm-broadcast/fm_broadcast_recording_20240615.c64
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq
    decim: decimation
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    name: RF spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1
    name: Spectrum after decimation
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 1,0
    label1: Before lowpass filter
    label2: After lowpass filter
    name: Spectrum after Quadrature Demod
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 2,0
    label1: In-phase
    label2: Quadrature
    name: Stereo subcarrier spectrum
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    name: Audio signal (mono)
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1
    label1: L + R (mono)
    label2: L - R (stereo signal)
    label3: L
    label4: R
    name: Audio signals
    nconnections: '4'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', low_pass_filter_1_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '3']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_sub_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', blocks_sub_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
