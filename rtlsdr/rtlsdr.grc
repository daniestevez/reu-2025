options:
  parameters:
    generate_options: qt_gui
    id: rtlsdr
    output_language: python
    title: RTL-SDR receiver
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_entry
  parameters:
    label: BB gain
    type: real
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: real
    value: 98.8e6
  states: {}
- name: if_gain
  id: variable_qtgui_entry
  parameters:
    label: IF gain
    type: real
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF gain
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3_200_000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: bb_gain
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
